require ${@bb.utils.contains('DISTRO_FEATURES', 'cloonix', 'busybox-inittab_cloonix.inc', '', d)}
