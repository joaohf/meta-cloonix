require ${@bb.utils.contains('DISTRO_FEATURES', 'cloonix', 'sysvinit-inittab_cloonix.inc', '', d)}
